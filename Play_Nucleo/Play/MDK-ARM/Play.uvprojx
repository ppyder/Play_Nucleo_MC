# Keil uVision project Play.uvprojx, settings and files
target Play (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F302R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Play +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302x8
  c include: ../Core/Inc;     ../Drivers/STM32F3xx_HAL_Driver/Inc;     ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;     ../Drivers/CMSIS/Include;     ..\HEROLIB\communication;     ..\HEROLIB\communication\com_dev;     ..\HEROLIB\communication\temp;     ..\HEROLIB\AS5048a;     ..\HEROLIB\io_operation;     ..\HEROLIB\io_operation\Key;     ..\HEROLIB\io_operation\LED;     ..\HEROLIB\algorithms\filter;     ..\APP\Key_user;     ..\APP\LED_user;     ..\APP\AD_Monitor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f302x8.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group APP/Devices
    ../APP/Key_user/: UserKey.c
    ../APP/LED_user/: UserLED.c
    ../APP/AD_Monitor/: AD_Monitor.c
  group HEROLIB/IO
    ../HEROLIB/io_operation/Key/: Key.c
    ../HEROLIB/io_operation/LED/: LED.c
    ../HEROLIB/AS5048a/: AS5048a.c
  group HEROLIB/COM
    ../HEROLIB/communication/com_dev/: com_can.c com_uart.c
    ../HEROLIB/communication/: communication.c uppercomputer.c
  group HEROLIB/Algorithms
    ../HEROLIB/algorithms/filter/: filter.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
software components: CMSIS:CORE 4.3.0
